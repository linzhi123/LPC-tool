# Keil uVision project USBComp_DFU_CDC.uvprojx, settings and files
target USBComp_Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC11U35FHI33/501 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IRAM2(0x20004000,0x0800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: USBComp +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x0)
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG_FLASH
  c include: ..\USBClass\DFU;..\USBClass\CDC;..\Common\inc;..\USBCore;..\USBComp_DFU_CDC;.\I2C
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group Startup
    ../Common/src/: core_cm0.c system_LPC11Uxx.c startup_LPC11Uxx.s
  group USBCore
    ../USBCore/: usbcore.c usbhw.c
  group USBClass
    ../USBClass/DFU/: dfuuser.c
    ../USBClass/CDC/: cdcuser.c
  group Application
    ./: serial.c sbl_iap.c demo.c usbuser.c usbdesc.c
  group Documentation
    ./: Abstract.txt
  group I2C
    ./I2C/: ADS1014.c ADS1100.c PCA9555.c LPC11xx_debug.c LPC11xx_uart.c
