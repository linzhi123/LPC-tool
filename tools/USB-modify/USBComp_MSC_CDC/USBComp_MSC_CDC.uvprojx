# Keil uVision project USBComp_MSC_CDC.uvprojx, settings and files
target USBComp_Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC11U35FHI33/501 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IRAM2(0x20004000,0x0800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: USBComp +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x0)
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc;..\USBCore;..\USBClass\CDC;..\USBClass\MSC
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group Startup
    ../Common/src/: core_cm0.c system_LPC11Uxx.c startup_LPC11Uxx.s
  group USBCore
    ../USBCore/: usbcore.c usbhw.c
  group USBClass
    ../USBClass/MSC/: mscuser.c
    ../USBClass/CDC/: cdcuser.c
  group Application
    ./: serial.c usbdesc.c usbuser.c demo.c DiskImg.c
  group Documentation
    ./: Abstract.txt
