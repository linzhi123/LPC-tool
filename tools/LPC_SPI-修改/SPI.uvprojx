# Keil uVision project SPI.uvprojx, settings and files
target SPI (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC11U35FHI33/501 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IRAM2(0x20004000,0x0800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SPI +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x0)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\drivers\common;.\drivers\lpc11xx\include;.\main;.\FPM
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group main
    ./main/: main.c
  group LIB
    ./LIB/: spi.c LPC11xx_uart.c LPC11xx_debug.c
    ./main/: sbl_master.c
  group FPM
    ./FPM/: fpm.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
