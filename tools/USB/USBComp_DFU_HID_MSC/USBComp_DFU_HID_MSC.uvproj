# Keil uVision project USBComp_DFU_HID_MSC.uvproj, settings and files
target USBComp_Release (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: USBHid +hex
  c flags: Optim=3
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc;..\USBCore;..\USBClass\DFU;..\USBClass\MSC;..\USBClass\HID
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  memory RVCT10: RAM 0x20004400 size 0x400
  group Startup
    ../Common/src/: core_cm0.c system_LPC11Uxx.c startup_LPC11Uxx.s
  group USBCore
    ../USBCore/: usbcore.c usbhw.c
  group USBClass
    ../USBClass/DFU/: dfuuser.c
    ../USBClass/HID/: hiduser.c
    ../USBClass/MSC/: mscuser.c
  group Application
    ./: DiskImg.c sbl_iap.c demo.c usbuser.c usbdesc.c
  group Documentation
    ./: Abstract.txt
