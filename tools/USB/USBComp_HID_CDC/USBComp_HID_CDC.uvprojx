# Keil uVision project USBComp_HID_CDC.uvprojx, settings and files
target USBComp_Release (ARM-ADS)
  device: LPC11U35FHI33/501 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x10000000,0x2000) IRAM2(0x20004000,0x0800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: USBComp +hex
  c flags: Optim=3
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc;..\USBCore;..\USBClass\HID;..\USBClass\CDC
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group Startup
    ../Common/src/: core_cm0.c system_LPC11Uxx.c startup_LPC11Uxx.s
  group USBCore
    ../USBCore/: usbcore.c usbhw.c
  group USBClass
    ../USBClass/HID/: hiduser.c
    ../USBClass/CDC/: cdcuser.c
  group Application
    ./: serial.c usbdesc.c usbuser.c demo.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 4.1.0
